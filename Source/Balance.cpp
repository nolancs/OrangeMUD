/******************************************************************************
  Author: Matthew Nolan                                      OrangeMUD Codebase
    Date: January 2001                                          [Crossplatform]
 License: MIT License

Permission is hereby granted, free of charge, to any person obtaining a copy
of this software and associated documentation files (the "Software"), to deal
in the Software without restriction, including without limitation the rights
to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
copies of the Software, and to permit persons to whom the Software is
furnished to do so, subject to the following conditions:

The above copyright notice and this permission notice shall be included in all
copies or substantial portions of the Software.

THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
SOFTWARE.

Copyright 2000-2019 Matthew Nolan, All Rights Reserved
******************************************************************************/
#include "CommonTypes.h"
#include "Attack.h"
#include "Balance.h"
#include "MobileIndex.h"
#include "ObjectIndex.h"
#include "Part.h"


void BalanceMobile(MobileIndex* hIndex, bool hNewAttacks)
{
    LONG i;

    
    //calculate statistics
    for(i = 0; i < kStatMax; ++i)
        hIndex->mStat[i] = hIndex->mStatMod[i] + (13 + hIndex->mLevel / 20);


    //calculate resistances
    for(i = 0; i < kResMax; ++i)
        hIndex->mResist[i] = hIndex->mResistMod[i]; // + (hIndex->mLevel / 10);


    //calculate hps, energy, moves
    HpAtLevel(hIndex->mLevel, hIndex->mHitsMod, &hIndex->mHits[0], &hIndex->mHits[1]);
    EnAtLevel(hIndex->mLevel, hIndex->mEnergyMod, &hIndex->mEnergy[0], &hIndex->mEnergy[1]);
    MvAtLevel(hIndex->mLevel, hIndex->mMovesMod, &hIndex->mMoves[0], &hIndex->mMoves[1]);
        
    
    //calculate attacks
    if(hNewAttacks)
    {
        hIndex->mAPR = 1 + hIndex->mLevel / 15;

        for(i = 0; i < hIndex->mAttacks.size(); ++i)
            delete hIndex->mAttacks[i];
        hIndex->mAttacks.resize(0);

        for(i = 0; i < hIndex->mAPR; ++i)
        {
            Attack* nAttack = new Attack();
            
            nAttack->mNumber        = i+1;
            nAttack->mMessage       = "attack";
            nAttack->mChance        = 100/hIndex->mAPR;
            nAttack->mType          = kAttTank;
            nAttack->mFlags         = 0;
            nAttack->mHitMod        = 100;
            nAttack->mDamMod        = 100;
            nAttack->mDamageType    = kDamPhysical;
            
            CalcAttack(nAttack, hIndex);
            hIndex->mAttacks.push_back(nAttack);
        }
    }
    else
    {
        for(i = 0; i < hIndex->mAttacks.size(); ++i)
            CalcAttack(hIndex->mAttacks[i], hIndex);
    }
    
    
    //calculate parts
    for(i = 0; i < hIndex->mParts.size(); ++i)
        CalcPart(hIndex->mParts[i], hIndex);
}



void BalanceObject(ObjectIndex* hIndex)
{
    switch(hIndex->mItemType)
    {
        case kItemWeapon:   BalanceWeapon(hIndex);  break;
        case kItemArmor:    BalanceArmor(hIndex);   break;
    }
}



void BalanceWeapon(ObjectIndex* hIndex)
{
    hIndex->mValue[kWeapMod] = 100;

    ASSERT(hIndex->mItemType == kItemWeapon);
    float nDamagePerRound   = float(HpAtLevel(hIndex->mLevel)) / 10.0f;
    float nRandomness       = UMAX(2.0f, nDamagePerRound * .10f);
    //above from CalcAttack()
    float nStandardACByLevel = float(nRandomness) / 2.0f;
    

    float nStandardDamByLevel = nStandardACByLevel * 1.75;
    float nStandardDamRandomness = UMAX(2.0f, nStandardDamByLevel * .10f);
    float nMinWeapDam = nStandardDamByLevel + nStandardDamRandomness;
    float nMaxWeapDam = nStandardDamByLevel - nStandardDamRandomness;
    nMinWeapDam *= float(hIndex->mValue[kWeapMod])/100.0f;
    nMaxWeapDam *= float(hIndex->mValue[kWeapMod])/100.0f;


    hIndex->mValue[kWeapMin] = nMinWeapDam;
    hIndex->mValue[kWeapMax] = nMaxWeapDam;
}




void BalanceArmor(ObjectIndex* hIndex)
{
    hIndex->mValue[kArmMod] = 100;
    
    ASSERT(hIndex->mItemType == kItemArmor);
    float nDamagePerRound   = float(HpAtLevel(hIndex->mLevel)) / 10.0f;
    float nRandomness       = UMAX(2.0f, nDamagePerRound * .10f);
    //above from CalcAttack()
    float nStandardACByLevel = float(nRandomness) / 2.0f;
    
    
    float nArmorAC = nStandardACByLevel * (float(hIndex->mValue[kArmMod]) / 100.0f);
    hIndex->mValue[kArmAC] = nArmorAC;
}




LONG HpAtLevel(LONG hLevel, float hMod, LONG* hMin, LONG* hMax)
{
    hMod /= 100.0f;
    LONG theMin = hMod * float(hLevel * kMobileHpPerLevel);
    LONG theMax = hMod * float(hLevel * kMobileHpPerLevel);

    theMin = UMAX(1, theMin);
    theMax = UMAX(1, theMax);
    
    if(hMin)
        *hMin = theMin;
    if(hMax)
        *hMax = theMax;
    
    return (theMin + theMax) / 2;
}




LONG EnAtLevel(LONG hLevel, float hMod, LONG* hMin, LONG* hMax)
{
    hMod /= 100.0f;
    LONG theMin = hMod * float(hLevel * kMobileEnPerLevel);
    LONG theMax = hMod * float(hLevel * kMobileEnPerLevel);
        
    if(hMin)
        *hMin = theMin;
    if(hMax)
        *hMax = theMax;
    
    return (theMin + theMax) / 2;
}




LONG MvAtLevel(LONG hLevel, float hMod, LONG* hMin, LONG* hMax)
{
    hMod /= 100.0f;
    LONG theMin = hMod * float(hLevel * kMobileMvPerLevel);
    LONG theMax = hMod * float(hLevel * kMobileMvPerLevel);
    
    if(hMin)
        *hMin = theMin;
    if(hMax)
        *hMax = theMax;
    
    return (theMin + theMax) / 2;
}




void CalcAttack(Attack* hAttack, MobileIndex* hIndex)
{
    float nDamagePerRound   = float(HpAtLevel(hIndex->mLevel)) / 10.0f;
    float nDamagePerAttack  = nDamagePerRound / float(hIndex->mAPR);
    float nRandomness       = UMAX(2.0f, nDamagePerAttack * .10f);

    float nHitMod = float(hAttack->mHitMod) / 100.0f;
    float nDamMod = float(hAttack->mDamMod) / 100.0f;
    
    hAttack->mHitroll[0] = UMIN(100, 75.0f * nHitMod); 
    hAttack->mHitroll[1] = UMIN(100, 85.0f * nHitMod); 
    hAttack->mDamroll[0] = (nDamagePerAttack-nRandomness) * nDamMod;
    hAttack->mDamroll[1] = (nDamagePerAttack+nRandomness) * nDamMod;
}




void CalcPart(Part* hPart, MobileIndex* hIndex)
{
    LONG nDamagePerRound    = HpAtLevel(hIndex->mLevel) / 10.0f;
    //LONG nDamagePerAttack = nDamagePerRound / min(hIndex->mAPR, (SHORT)1);
    LONG nRandomness        = UMAX(2.0f, float(nDamagePerRound) * .10f);
    //above from CalcAttack()
    float nStandardACByLevel = float(nRandomness) / 2.0f;
    float nACMod = float(hPart->mACMod) / 100.0f;
    
    hPart->mAC = nStandardACByLevel * nACMod;
}


